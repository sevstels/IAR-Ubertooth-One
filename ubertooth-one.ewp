# IAR project ubertooth-one.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1756 NXP LPC1756
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: UBERTOOTH_ONE; TX_ENABLE; NO_DEBUG; LPC17xx
  ICCARM.CCIncludePath2: src\; src\ubertooth; src\ubertooth\cs; src\ubertooth\usb; src\ubertooth\dma; src\ubertooth\rssi; src\ubertooth\clock; src\bluetooth\classic; src\bluetooth\ble; src\ego; src\rx-tx; src\usb-driver; src\usb-serial; src\bootloader; src\bt-tx; src\fifo; src\lpc1756; src\cc2400; src\libubertooth; src\headers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ubertooth-one.hex
  ILINK.IlinkOutputFile: ubertooth.out
  ILINK.IlinkIcfFile: src\linker-file\ubertooth-flash.icf
  ILINK.IlinkExtraOptions: --log sections
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; UBERTOOTH_ONE; TX_ENABLE; LPC17xx
  ICCARM.CCIncludePath2: src\; src\ubertooth; src\ubertooth\cs; src\ubertooth\usb; src\ubertooth\dma; src\ubertooth\rssi; src\ubertooth\clock; src\bluetooth\classic; src\bluetooth\ble; src\ego; src\rx-tx; src\usb-driver; src\usb-serial; src\bootloader; src\bt-tx; src\fifo; src\lpc1756; src\cc2400; src\libubertooth
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: ubertooth-one.srec
  ILINK.IlinkOutputFile: cpp.out
  group (top)
    src/: bluetooth_rxtx.c
  group Bluetooth/classic
    src/bluetooth/classic/: bluetooth.c bluetooth.h
  group Bluetooth/low energy
    src/bluetooth/ble/: bluetooth_le.c bluetooth_le.h
  group bt tx
    src/bt-tx/: bt-tx.h dm3-tx.c syncword.c
  group cc2400
    src/cc2400/: cc2400.h cc2400_rangetest.c cc2400_rangetest.h
  group ego
    src/ego/: ego.c ego.h
  group fifo
    src/fifo/: serial_fifo.c serial_fifo.h
  group Headers
    src/headers/: revision.h types.h
  group Lib ubertooth
    src/libubertooth/: ubertooth_interface.h
  group Linker file
    src/linker-file/: LPC17xx_Linker_Script_with_bootloader.ld sections.ld ubertooth-flash.icf ubertooth-ram.icf ubertooth-with-bootloader.icf
  group lpc1756
    src/lpc1756/: lpc17.h lpc17_startup.s lpc17_system.c lpc17_system.h
  group Ubertooth
    src/ubertooth/: ubertooth.c ubertooth.h
  group Ubertooth/clock
    src/ubertooth/clock/: ubertooth_clock.c ubertooth_clock.h
  group Ubertooth/cs
    src/ubertooth/cs/: ubertooth_cs.c ubertooth_cs.h
  group Ubertooth/dma
    src/ubertooth/dma/: ubertooth_dma.c ubertooth_dma.h
  group Ubertooth/rssi
    src/ubertooth/rssi/: ubertooth_rssi.c ubertooth_rssi.h
  group Ubertooth/usb
    src/ubertooth/usb/: ubertooth_usb.c ubertooth_usb.h
  group usb diver
    src/usb-driver/: debug.h type.h usbapi.h usbcontrol.c usbhw_lpc.c usbhw_lpc.h usbinit.c usbstdreq.c usbstruct.h
  group usb serial
    src/usb-serial/: usb_serial.c usb_serial.h
